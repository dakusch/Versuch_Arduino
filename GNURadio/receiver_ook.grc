options:
  parameters:
    generate_options: qt_gui
    id: receiver_ook
    output_language: python
    title: Signal Visualizer
  states: {}

blocks:
- name: decim
  id: variable
  parameters:
    value: '100'
  states: {}
- name: frequency
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 'Tabs@0: 3,3,1,1'
    label: Frequenzen
    label0: 40 MHz
    label1: 433 MHz
    label2: 868 MHz
    num_opts: '3'
    option0: '40000000'
    option1: '433000000'
    option2: '868000000'
    orient: Qt.QHBoxLayout
    type: real
    value: '40000000'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: trig_lvl
  id: variable_qtgui_range
  parameters:
    gui_hint: 'Tabs@0: 3,3,1,1'
    label: Trigger Level
    start: '0'
    step: '0.001'
    stop: '0.5'
    value: '0.1'
    widget: eng_slider
  states: {state: disabled}
- name: Tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: '[0,0,1,1]'
    label0: Zeitsignal
    label1: Tab2
    num_tabs: '2'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: 1/100
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '500'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 'Tabs@1: 1,1,1,1'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    grid: 'True'
    gui_hint: 'Tabs@0: 1,2,2,3'
    label1: Signal
    name: '"Signal im Zeitbereich"'
    size: '10000'
    srate: samp_rate/decim
    tr_level: '0'
    type: float
    update_time: '0.1'
    ymin: '-0.2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'Tabs@0: 1,1,3,1'
    name: '"Wasserfall Diagramm"'
    type: float
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decim
    interp: '1'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_moving_average_xx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_moving_average_xx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
